# Keil uVision project 07B-demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F340 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: 07B-demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: flash_w.a51 main.c
